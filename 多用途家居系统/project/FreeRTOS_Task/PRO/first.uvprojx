# Keil uVision project first.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: first +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\STM32F4xx_Lib\inc;..\Hardware;..\FreeRTOS_Source;..\FreeRTOS_Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c
  group Hardware
    ../Hardware/: led.c delay.c key.c beep.c tim.c uart.c adc.c at24c02.c flash.c iic.c mqtt.c oled.c spi.c ymodem.c dht11.c rtc.c motor.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STM32F4xx_Lib
    ../STM32F4xx_Lib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c
  group FreeRTOS_Source
    ../FreeRTOS_Source/: heap_4.c list.c port.c queue.c tasks.c
